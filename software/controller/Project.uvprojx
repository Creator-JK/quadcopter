# Keil uVision project Project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::.\arm 5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\user;.\startup;.\stdlib;.\freeRTOS\include;.\freeRTOS\portable\RVDS\ARM_CM3;.\sys;.\dri
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group startup
    ./startup/: startup_stm32f10x_md.s system_stm32f10x.c stm32f10x_core_cm3.c stm32f10x.h system_stm32f10x.h stm32f10x_core_cm3.h
  group dri
    ./dri/: dri_nrf24l01.c dri_nrf24l01.h dri_serial.c dri_serial.h
  group sys
    ./sys/: sys_task.c sys_task.h sys.c sys.h
  group freeRTOS
    ./freeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./freeRTOS/portable/MemMang/: heap_4.c
    ./freeRTOS/portable/RVDS/ARM_CM3/: port.c portmacro.h
    ./freeRTOS/include/: FreeRTOSConfig.h
  group stdlib
    ./stdlib/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_misc.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_misc.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
